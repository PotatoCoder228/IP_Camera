## general/package/our-script/Config.in
```kconfig
config BR2_PACKAGE_OUR_SCRIPT
	bool "our-script"
	default n
	help
	  Our UART script

	  https://openipc.org
```
